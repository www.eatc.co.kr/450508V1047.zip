# Autodesk Inventor assembly: 조립품2
## iProperties
Created: 2015-05
Part Number: 조립품2
Document SubType Name: Assembly
Designer: Administrator
Author: Administrator
